# Repository Oleh-Subbota/temper34

## KiCad design pcb/chocofi.kicad_pcb

Board: 2 copper layers, 111.3 x 90.0 mm, 57 parts (6 on the bottom side), 39 nets.

Parts:
D2, D3, D4, D5, D6, D8, D9, D10, D11, D12, D14, D15, D16, D17, D18, D20, D21: D; D3_TH_SMD
H1: h1; LEGO_HOLE
J1: MJ-4PP-9
J2: OLED
J3: Conn_01x02_Female; Battery_TH
JP6, JP61: SDA; Jumper
JP61#2, JP62#2: RAW; Jumper
JP62, JP68: GND; Jumper
JP63, JP66: SCL; Jumper
JP64, JP65: VCC; Jumper
RSW1: Val**; ResetSW
SW1, SW2#2: SW_SPDT; SW_SPDT+H-MSK12C01_hor(7pin_SMD)
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21: SW_PUSH; Kailh_socket_PG1350_reversible
U1: ProMicro; ProMicro_v2
h2: h2; LEGO_HOLE
h3: h3; LEGO_HOLE
h5: h5; LEGO_HOLE
h6: h6; LEGO_HOLE
h7: h7; LEGO_HOLE

Connections:
BAT_PLUS: J3.2, JP61#2.2, JP62#2.2
GND: J1.C, J3.1, JP62.1, JP68.1, RSW1.1, U1.3, U1.4, U1.23
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: J2.3, JP65.2, JP66.2
unnamed: J2.4, JP6.2, JP68.2
unnamed: J2.2, JP63.2, JP64.2
unnamed: J2.1, JP61.2, JP62.2
unnamed: SW1.2 (B), SW2#2.2 (B), U1.24
SCL: JP63.1, JP66.1, U1.6
SDA: JP6.1, JP61.1, U1.5
SW_RAW_2: JP61#2.1, SW1.3 (C)
VCC: J1.D, JP64.1, JP65.1, U1.21
col1: SW2.1, SW8.1, SW14.1, U1.19
col2: SW3.1, SW9.1, SW15.1, U1.18
col3: SW4.1, SW10.1, SW16.1, U1.17
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15
data: J1.B, U1.2
reset: RSW1.2, U1.22
row0: D2.1, D3.1, D4.1, D5.1, D6.1, U1.7
row1: D8.1, D9.1, D10.1, D11.1, D12.1, U1.8
row2: D14.1, D15.1, D16.1, D17.1, D18.1, U1.9
row3: D20.1, D21.1, U1.10

## Commit log (part)

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2025-06-15 init commit
2025-06-15 adjutsting the forlder structure
2025-06-15 adding build files
2025-06-15 editing keymap
2025-06-15 adding github build action
2025-06-16 fixing bt keycode
2025-06-17 lettle keymap changes
2025-06-17 testing sticky layer
2025-06-17 adding 3sec release timeout to bt sl
2025-06-17 removed release timeout for bt sl
2025-06-17 moving fn keys
2025-06-17 shifting hmr on nam layer
2025-06-17 fixed keycode error
2025-07-01 added case files
2025-07-01 adding a mirrored case half
2025-07-01 adding separate case halfs
2025-07-02 adding dvorak
2025-07-02 fixing U on dvorak
2025-07-02 modifying dvorak
2025-07-02 replacing dvorak with ahei
2025-07-03 fixing mistake in colemak-dh
2025-07-28 rename to temper34
2025-07-28 changing build name
2025-08-13 trying only one util layer
2025-08-14 using lt for a single layer access
2025-08-14 fixing tdbt behaviour
2025-08-14 trying dvorak
2025-08-15 fixing lt for util layer
2025-08-20 trying poutea
2025-08-20 customizing colemak
2025-08-24 custom layout colepoq
2025-08-24 custom layout colepoq v0.2
2025-09-30 rearranging brackets in the layer 2
2025-12-01 adding a separate pipe and swapping rshft and rgui
2026-02-09 slight changes to layer two
2026-02-09 changing revision to v0.3
2026-02-09 adding keymap to ./config
2026-02-09 testing LONG behaviour
2026-02-09 adding gt_btclr behaviour
2026-02-09 Refactor gt_btclr to lp with updated bindings
2026-02-09 adding third layer for bt only
2026-02-09 cleanup
2026-03-26 trying out "hands down" layout
2026-04-01 trying new test layout
2026-04-06 changing default layout
2026-04-28 giving : and ; its own separate key
2026-06-02 Changing hrm flavour. Moving the ; symbol
